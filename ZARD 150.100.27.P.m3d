# KOMPAS-3D part (ZARD 150.100.27.P.m3d)

Model tree:
1. Булева операция:1
2. Булева операция:2
